# Keil uVision project ttrd_eres02.uvprojx, settings and files
target STM32F407VG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TTRD-ERES2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F40_41xxx USE_FULL_ASSERT USE_STDPERIPH_DRIVER HSE_VALUE=8000000 CORTEX
  c include: ..\source\hsi_library; ..\source\hsi_startup
  asm define: CORTEX
  asm include: ..\source\startup;..\source\cora\hwt\inc;..\source\cora\hwt\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../source/main/: main.c main.h
  group port
    ../source/port/: port.h
  group support_functions
    ../source/support_functions/: ttrd2-05a-t0401a-v001a_timeout_t3.c ttrd2-05a-t0401a-v001a_timeout_t3.h ax_25.c ax_25.h cw.c cw.h stats.c stats.h services.c services.h upsat.h upsat.c wod_handling.c wod_handling.h config.h large_data_services.h sha256.c sha256.h large_data_services.c
  group tasks
    ../source/tasks/: ttrd2-05a-t0401a-v001a_adc_task.c ttrd2-05a-t0401a-v001a_adc_task.h ttrd2-05a-t0401a-v001a_heartbeat_sw_task.c ttrd2-05a-t0401a-v001a_heartbeat_sw_task.h ttrd2-05a-t0401a-v001a_iwdt_task.c ttrd2-05a-t0401a-v001a_iwdt_task.h ttrd2-05a-t0401a-v001a_switch_task.c ttrd2-05a-t0401a-v001a_switch_task.h ttrd2-05a-t0401a-v001a_uart2_buff_o_task.c ttrd2-05a-t0401a-v001a_uart2_buff_o_task.h ttrd2-19a-t0401a-v001b_processor_task.c ttrd2-19a-t0401a-v001b_processor_task.h comms_manager.c comms_manager.h tx_manager.c tx_manager.h rx_manager.c rx_manager.h TickCounter.c TickCounter.h cc_rx.c cc_rx.h cc_tx.c cc_tx.h obc_comm.c obc_comm.h
  group hsi_library
    ../source/hsi_library/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_spi.c stm32f4xx_fsmc.h stm32f4xx_fsmc.c
  group hsi_reg_config_checks
    ../source/hsi_reg_config_checks/: ttrd2-05a-t0401a-v001a_reg_conf_chk_adc1.c ttrd2-05a-t0401a-v001a_reg_conf_chk_adc1.h ttrd2-05a-t0401a-v001a_reg_conf_chk_gpio.c ttrd2-05a-t0401a-v001a_reg_conf_chk_gpio.h ttrd2-05a-t0401a-v001a_reg_conf_chk_timer.c ttrd2-05a-t0401a-v001a_reg_conf_chk_timer.h ttrd2-05a-t0401a-v001a_reg_conf_chk_uart.c ttrd2-05a-t0401a-v001a_reg_conf_chk_uart.h
  group hsi_startup
    ../source/hsi_startup/: system_stm32f4xx.c ttrd2-19a-t0401a-v001a_assert_failed.c startup_stm32f407xx.s
  group processor
    ../source/processor/: ttrd2-04a-t0401a-v001a_pfc_reporting.c ttrd2-04a-t0401a-v001a_pfc_reporting.h ttrd2-19a-t0401a-v001b_processor.c ttrd2-19a-t0401a-v001b_processor.h ttrd2-19a-t0401a-v001b_run_time_tests.c ttrd2-19a-t0401a-v001b_run_time_tests.h
  group scheduler
    ../source/scheduler/: ttrd2-18a-t0401a-v001a_monittor_i.c ttrd2-18a-t0401a-v001a_monittor_i.h ttrd2-19a-t0401a-v001b_predicttor_i.c ttrd2-19a-t0401a-v001b_predicttor_i.h ttrd2-19a-t0401a-v001b_predicttor_i_tick_list.h ttrd2-19a-t0401a-v001c_scheduler.c ttrd2-19a-t0401a-v001c_scheduler.h
