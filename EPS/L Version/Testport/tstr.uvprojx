# Keil uVision project tstr.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RBTx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tstr
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32L152RBTx/STCubeGenerated/Src/: main.c stm32l1xx_it.c
    ./RTE/Device/STM32L152RBTx/STCubeGenerated/Inc/: stm32l1xx_it.h
software components: CMSIS:CORE 5.5.0, Device:STM32Cube HAL 1.10.3, Board Support:Buttons 1.1.0
