# Keil uVision project dummyl152.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L152RBTx STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.4.1
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dummyl152
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, Device:STM32Cube Framework:STM32CubeMX 1.10.3, Device:Startup 1.10.3
