# Keil uVision project ttrd_eres02.uvprojx, settings and files
target STM32F446RE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TTRD-ERES2
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT USE_STDPERIPH_DRIVER HSE_VALUE=8000000 CORTEX USE_HSE_BYPASS
  c include: ..\source\hsi_library; ..\source\hsi_startup
  asm define: CORTEX
  asm include: ..\source\startup;..\source\cora\hwt\inc;..\source\cora\hwt\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group main
    ../source/main/: main.c main.h project.c project.h
  group port
    ../source/port/: port.h
  group support_functions
    ../source/support_functions/: ttrd2-05a-t0401a-v001a_timeout_t3.c ttrd2-05a-t0401a-v001a_timeout_t3.h
  group tasks
    ../source/tasks/: ttrd2-05a-t0401a-v001a_adc_task.c ttrd2-05a-t0401a-v001a_adc_task.h ttrd2-05a-t0401a-v001a_heartbeat_sw_task.c ttrd2-05a-t0401a-v001a_heartbeat_sw_task.h ttrd2-05a-t0401a-v001a_iwdt_task.c ttrd2-05a-t0401a-v001a_iwdt_task.h ttrd2-05a-t0401a-v001a_switch_task.c ttrd2-05a-t0401a-v001a_switch_task.h ttrd2-05a-t0401a-v001a_uart2_buff_o_task.c ttrd2-05a-t0401a-v001a_uart2_buff_o_task.h ttrd2-19a-t0401a-v001b_processor_task.c ttrd2-19a-t0401a-v001b_processor_task.h apptask_uart_hello.c apptask_uart_hello.h app_sensor_gps_task.c app_sensor_gps_task.h app_sensor_imu_task.c app_sensor_imu_task.h app_sensor_mgn_task.c app_sensor_mgn_task.h app_sensor_tmp_task.c app_sensor_tmp_task.h app_actuators_task.c app_control_attitude_det_task.c app_actuators_task.h app_control_attitude_det_task.h app_control_attitude_update_task.c app_control_attitude_update_task.h app_control_ref_vector_task.c app_control_ref_vector_task.h app_control_sgp4_task.c app_control_tle_task.c app_control_sgp4_task.h app_control_tle_task.h app_obc_comm_task.h app_sensor_health_task.c app_sensor_health_task.h app_sensor_sun_task.h app_sensor_sun_task.c app_obc_comm_task.c app_time_keeping_task.h app_time_keeping_task.c
  group hsi_library
    ../source/hsi_library/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group hsi_reg_config_checks
    ../source/hsi_reg_config_checks/: ttrd2-05a-t0401a-v001a_reg_conf_chk_adc1.c ttrd2-05a-t0401a-v001a_reg_conf_chk_adc1.h ttrd2-05a-t0401a-v001a_reg_conf_chk_gpio.c ttrd2-05a-t0401a-v001a_reg_conf_chk_gpio.h ttrd2-05a-t0401a-v001a_reg_conf_chk_timer.c ttrd2-05a-t0401a-v001a_reg_conf_chk_timer.h ttrd2-05a-t0401a-v001a_reg_conf_chk_uart.c ttrd2-05a-t0401a-v001a_reg_conf_chk_uart.h
  group hsi_startup
    ../source/hsi_startup/: system_stm32f4xx.c ttrd2-19a-t0401a-v001a_assert_failed.c startup_stm32f446xx.s
  group processor
    ../source/processor/: ttrd2-04a-t0401a-v001a_pfc_reporting.c ttrd2-04a-t0401a-v001a_pfc_reporting.h ttrd2-19a-t0401a-v001b_processor.c ttrd2-19a-t0401a-v001b_processor.h ttrd2-19a-t0401a-v001b_run_time_tests.c ttrd2-19a-t0401a-v001b_run_time_tests.h
  group scheduler
    ../source/scheduler/: ttrd2-18a-t0401a-v001a_monittor_i.c ttrd2-18a-t0401a-v001a_monittor_i.h ttrd2-19a-t0401a-v001b_predicttor_i.c ttrd2-19a-t0401a-v001b_predicttor_i.h ttrd2-19a-t0401a-v001b_predicttor_i_tick_list.h ttrd2-19a-t0401a-v001c_scheduler.c ttrd2-19a-t0401a-v001c_scheduler.h
  group adcs_sensors
    ../source/adcs/adcs_sensors/: gps_sensor.h imu_sensor.h mgn_sensor.h tmp_sensor.h sun_sensor.h imu_sensor.c driver_i2c.c driver_i2c.h mgn_sensor.c gps_sensor.c tmp_sensor.c sun_sensor.c
  group services_utilities
    ../source/adcs/services_utilities/: services.h time.h services_utilities.h common.h flash.h time.c flash.c common.c nmea_parsing.h nmea_parsing.c obc_comm.h obc_comm.c
  group adcs_actuators
    ../source/adcs/adcs_actuators/: mgn_torquer_driver.h spin_motor_driver.h mgn_torquer_driver.c spin_motor_driver.c
  group adcs_controller
    ../source/adcs/adcs_controller/: frame.h ref_vectors.h sgp4.h wahbaRotM.h frame.c ref_vectors.c controller.c controller.h WahbaRotM.c jacobiTS.c sgp4.c tle.h tle.c geomag.h geomag.c
  group adcs_config
    ../source/adcs/: config.h
